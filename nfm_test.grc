options:
  parameters:
    generate_options: qt_gui
    id: nfm_test
    output_language: python
    realtime_scheduling: '1'
    title: NFM Test
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: bbgain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Baseband Gain
    type: int
    value: '16'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency
    type: int
    value: int(def_freq)
  states: {}
- name: def_freq
  id: variable
  parameters:
    value: 442.85e6
  states: {}
- name: def_volume
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ifgain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: IF Gain
    type: int
    value: '16'
  states: {}
- name: lowpass_decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rfgain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,1,1,1
    label: RF Amp
    'true': '14'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e5
  states: {}
- name: volume_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Volume
    min_len: '10'
    start: '0'
    step: '0.1'
    stop: '1'
    value: def_volume
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(audio_rate)
    max_dev: 5e3
    quad_rate: int(audio_rate * lowpass_decimation)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate * 2)
  states: {}
- name: blocks_correctiq_auto_0
  id: blocks_correctiq_auto
  parameters:
    freq: center_freq
    gain: float(hash((rfgain,ifgain,bbgain)))
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_multiplier
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: lowpass_decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: bbgain
    freq0: center_freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: ifgain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,0,1,3
    label1: RF
    name: RF Input
    showports: 'True'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '2'
    fc: center_freq
    fftsize: '2048'
    gui_hint: 3,0,1,3
    int_max: '0'
    int_min: '-100'
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.05'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_correctiq_auto_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_auto_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_correctiq_auto_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_auto_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
